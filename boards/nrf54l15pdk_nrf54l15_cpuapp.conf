## boards/nrf54l15pdk_nrf54l15_cpuapp.conf
```kconfig
CONFIG_NRFX_DPPI=y
CONFIG_NRFX_TIMER20=y
CONFIG_NRFX_GPIOTE20=y

CONFIG_NRFX_TIMER0=n
CONFIG_NRFX_GPIOTE0=n
```
